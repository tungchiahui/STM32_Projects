# Keil uVision project Keyboard.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Keyboard
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=8000000 USE_STM32469I_DISCO_REVB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c Keyboard.c stdout_display.c
  group Documentation
    ./: Abstract.txt
target Release (6160000::V6.16::ARMCLANG)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: Keyboard
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=8000000 USE_STM32469I_DISCO_REVB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Board Support:Components:NT35510 1.0.0, Board Support:Components:OTM8009A 1.0.4, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:LCD 1.0.0, Board Support:Drivers:SDRAM 1.0.0, Board Support:Graphic LCD 1.0.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, USB:CORE 6.15.0, USB:CORE 6.15.0, USB:Host 6.15.0, USB:Host:HID 6.15.0, CMSIS Driver:USB Host:Full-speed 2.23, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:ADC 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:DMA2D 1.7.13, Device:STM32Cube HAL:DSI 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:I2C 1.7.13, Device:STM32Cube HAL:LTDC 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SDRAM 1.7.13, Device:STM32Cube HAL:SRAM 1.7.13, Device:Startup 2.6.3
