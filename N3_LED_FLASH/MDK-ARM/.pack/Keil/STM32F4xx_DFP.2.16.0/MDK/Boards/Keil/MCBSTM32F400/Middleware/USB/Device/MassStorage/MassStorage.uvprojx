# Keil uVision project MassStorage.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c MassStorage.c MemoryDiskImage.c USBD_User_MSC_0.c USBD_User_MSC_1.c
  group Documentation
    ./: Abstract.txt
target Release (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: MassStorage
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Board Support:Graphic LCD 2.0.0, File System:CORE 6.14.1, File System:CORE 6.14.1, File System:Drive:Memory Card 6.14.1, USB:CORE 6.15.0, USB:CORE 6.15.0, USB:Device 6.15.0, USB:Device:MSC 6.15.0, CMSIS Driver:MCI 2.10, CMSIS Driver:USB Device:Full-speed 2.22, CMSIS Driver:USB Device:High-speed 2.25, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SRAM 1.7.13, Device:Startup 2.6.3
