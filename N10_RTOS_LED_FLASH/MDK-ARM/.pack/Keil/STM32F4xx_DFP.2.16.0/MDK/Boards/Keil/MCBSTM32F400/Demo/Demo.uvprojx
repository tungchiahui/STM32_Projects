# Keil uVision project Demo.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Graphics
    ./: Button_16bpp.c Bulb_16bpp.c
  group Source Files
    ./: Demo.c main.c
  group Documentation
    ./: Abstract.txt
target Release (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: Demo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Board Support:A/D Converter 2.0.0, Board Support:Accelerometer 2.0.0, Board Support:Buttons 2.0.0, Board Support:Camera 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:Gyroscope 2.0.0, Board Support:Joystick 2.0.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, CMSIS Driver:I2C 2.11, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:ADC 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DCMI 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:I2C 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SRAM 1.7.13, Device:Startup 2.6.3
