# Keil uVision project GUIDemo.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GUIDemo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000 DATA_IN_ExtSRAM JOYSTICK_ROTATE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c
    ./: GUIDemo.c
  group Documentation
    ./: Abstract.txt
target Release (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: GUIDemo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000 DATA_IN_ExtSRAM JOYSTICK_ROTATE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Board Support:Joystick 2.0.0, Board Support:Touchscreen 2.0.0, Board Support:emWin LCD 2.0.0, CMSIS Driver:I2C 2.11, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:I2C 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SRAM 1.7.13, Device:Startup 2.6.3, Graphics:CORE 6.20.2, Graphics:Demo:Automotive 6.20.2, Graphics:Demo:BarGraph 6.20.2, Graphics:Demo:Bitmap 6.20.2, Graphics:Demo:ColorBar 6.20.2, Graphics:Demo:Cursor 6.20.2, Graphics:Demo:Fading 6.20.2, Graphics:Demo:Framework 6.20.2, Graphics:Demo:Graph 6.20.2, Graphics:Demo:ListView 6.20.2, Graphics:Demo:RadialMenu 6.20.2, Graphics:Demo:Skinning 6.20.2, Graphics:Demo:Speed 6.20.2, Graphics:Demo:Speedometer 6.20.2, Graphics:Demo:TransparentDialog 6.20.2, Graphics:Demo:Treeview 6.20.2, Graphics:Demo:WashingMachine 6.20.2, Graphics:Display:MCBQVGA_LG 6.20.2, Graphics:Input Device:Joystick 6.20.2, Graphics:Input Device:Touchscreen 6.20.2
